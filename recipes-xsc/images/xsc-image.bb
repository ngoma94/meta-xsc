IMAGE_INSTALL = "\
                ${CORE_IMAGE_EXTRA_INSTALL} \
                packagegroup-core-boot \
                bootgen \
                "

inherit core-image